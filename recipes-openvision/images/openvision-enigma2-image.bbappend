EXTRA_KERNEL_WIFI_DRIVERS_remove_ventonhdx = "\
	kernel-module-r8188eu \
	"

EXTRA_KERNEL_WIFI_DRIVERS_remove_beyonwizt3 = "\
	kernel-module-r8188eu \
	"

EXTRA_KERNEL_WIFI_DRIVERS_remove_mbtwin = "\
	kernel-module-r8188eu \
	"

EXTRA_KERNEL_WIFI_DRIVERS_remove_sezam5000hd = "\
	kernel-module-r8188eu \
	"
