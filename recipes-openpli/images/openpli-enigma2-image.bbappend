IMAGE_INSTALL_remove_beyonwizt3 = " \
	kernel-module-r8188eu \
	"

IMAGE_INSTALL_remove_ventonhdx = " \
	kernel-module-r8188eu \
	"

IMAGE_INSTALL_remove_sezam5000hd = " \
	kernel-module-r8188eu \
	"

IMAGE_INSTALL_remove_mbtwin = " \
	kernel-module-r8188eu \
	"

